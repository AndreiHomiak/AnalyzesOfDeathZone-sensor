<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sensor-adz-0-5.ewp</path>
    </project>
    <batchBuild />
</workspace>
